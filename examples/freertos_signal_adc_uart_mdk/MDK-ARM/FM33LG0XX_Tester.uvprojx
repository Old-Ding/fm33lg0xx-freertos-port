# Keil uVision project FM33LG0XX_Tester.uvprojx, settings and files
target Example (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: FM33LG02X FMSH
  pack: FMSH.FM33LG0XX_DFP.3.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33LG0xx_Tester +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: FM33LG0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Drivers\FM33LG0xx_FL_Driver\Inc;..\MF-config\Inc;..\Inc;..\..\..\FreeRTOS-Kernel-main\include;..\..\..\FreeRTOS-Kernel-main\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.c adc.c gpio.c taskadc.c taskgpio.c uart.c iwdt.c rmu.c svd.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group Drivers/FM33LG0xx_FL_Driver
    ../Drivers/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_wwdt.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_vrefp.c
  group Middlewares/FreeRTOS
    ../../../FreeRTOS-Kernel-main/: tasks.c list.c queue.c
    ../../../FreeRTOS-Kernel-main/portable/RVDS/ARM_CM0/: port.c
    ../../../FreeRTOS-Kernel-main/portable/MemMang/: heap_4.c
